# Keil uVision project level.uvprojx, settings and files
target level (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: level +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/: main.c stm32f10x_it.c stm32f10x_conf.h delay.c delay.h i2c.c i2c.h led.c led.h oled.c oled.h oledfont.h mpu6050.c mpu6050.h buzzer.c buzzer.h controls.c controls.h dht11.c dht11.h w25qxx.c w25qxx.h logger.c logger.h eventlog.c eventlog.h dashboard.c dashboard.h
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 6.2.0
